* tristate_inv_delay_line_128
* Schematic generated by Substrate

.subckt tristate_inv_delay_line_128
+ clk_in
+ clk_out
+ ctl[0]
+ ctl[1]
+ ctl[2]
+ ctl[3]
+ ctl[4]
+ ctl[5]
+ ctl[6]
+ ctl[7]
+ ctl[8]
+ ctl[9]
+ ctl[10]
+ ctl[11]
+ ctl[12]
+ ctl[13]
+ ctl[14]
+ ctl[15]
+ ctl[16]
+ ctl[17]
+ ctl[18]
+ ctl[19]
+ ctl[20]
+ ctl[21]
+ ctl[22]
+ ctl[23]
+ ctl[24]
+ ctl[25]
+ ctl[26]
+ ctl[27]
+ ctl[28]
+ ctl[29]
+ ctl[30]
+ ctl[31]
+ ctl[32]
+ ctl[33]
+ ctl[34]
+ ctl[35]
+ ctl[36]
+ ctl[37]
+ ctl[38]
+ ctl[39]
+ ctl[40]
+ ctl[41]
+ ctl[42]
+ ctl[43]
+ ctl[44]
+ ctl[45]
+ ctl[46]
+ ctl[47]
+ ctl[48]
+ ctl[49]
+ ctl[50]
+ ctl[51]
+ ctl[52]
+ ctl[53]
+ ctl[54]
+ ctl[55]
+ ctl[56]
+ ctl[57]
+ ctl[58]
+ ctl[59]
+ ctl[60]
+ ctl[61]
+ ctl[62]
+ ctl[63]
+ ctl[64]
+ ctl[65]
+ ctl[66]
+ ctl[67]
+ ctl[68]
+ ctl[69]
+ ctl[70]
+ ctl[71]
+ ctl[72]
+ ctl[73]
+ ctl[74]
+ ctl[75]
+ ctl[76]
+ ctl[77]
+ ctl[78]
+ ctl[79]
+ ctl[80]
+ ctl[81]
+ ctl[82]
+ ctl[83]
+ ctl[84]
+ ctl[85]
+ ctl[86]
+ ctl[87]
+ ctl[88]
+ ctl[89]
+ ctl[90]
+ ctl[91]
+ ctl[92]
+ ctl[93]
+ ctl[94]
+ ctl[95]
+ ctl[96]
+ ctl[97]
+ ctl[98]
+ ctl[99]
+ ctl[100]
+ ctl[101]
+ ctl[102]
+ ctl[103]
+ ctl[104]
+ ctl[105]
+ ctl[106]
+ ctl[107]
+ ctl[108]
+ ctl[109]
+ ctl[110]
+ ctl[111]
+ ctl[112]
+ ctl[113]
+ ctl[114]
+ ctl[115]
+ ctl[116]
+ ctl[117]
+ ctl[118]
+ ctl[119]
+ ctl[120]
+ ctl[121]
+ ctl[122]
+ ctl[123]
+ ctl[124]
+ ctl[125]
+ ctl[126]
+ ctl[127]
+ ctl_b[0]
+ ctl_b[1]
+ ctl_b[2]
+ ctl_b[3]
+ ctl_b[4]
+ ctl_b[5]
+ ctl_b[6]
+ ctl_b[7]
+ ctl_b[8]
+ ctl_b[9]
+ ctl_b[10]
+ ctl_b[11]
+ ctl_b[12]
+ ctl_b[13]
+ ctl_b[14]
+ ctl_b[15]
+ ctl_b[16]
+ ctl_b[17]
+ ctl_b[18]
+ ctl_b[19]
+ ctl_b[20]
+ ctl_b[21]
+ ctl_b[22]
+ ctl_b[23]
+ ctl_b[24]
+ ctl_b[25]
+ ctl_b[26]
+ ctl_b[27]
+ ctl_b[28]
+ ctl_b[29]
+ ctl_b[30]
+ ctl_b[31]
+ ctl_b[32]
+ ctl_b[33]
+ ctl_b[34]
+ ctl_b[35]
+ ctl_b[36]
+ ctl_b[37]
+ ctl_b[38]
+ ctl_b[39]
+ ctl_b[40]
+ ctl_b[41]
+ ctl_b[42]
+ ctl_b[43]
+ ctl_b[44]
+ ctl_b[45]
+ ctl_b[46]
+ ctl_b[47]
+ ctl_b[48]
+ ctl_b[49]
+ ctl_b[50]
+ ctl_b[51]
+ ctl_b[52]
+ ctl_b[53]
+ ctl_b[54]
+ ctl_b[55]
+ ctl_b[56]
+ ctl_b[57]
+ ctl_b[58]
+ ctl_b[59]
+ ctl_b[60]
+ ctl_b[61]
+ ctl_b[62]
+ ctl_b[63]
+ ctl_b[64]
+ ctl_b[65]
+ ctl_b[66]
+ ctl_b[67]
+ ctl_b[68]
+ ctl_b[69]
+ ctl_b[70]
+ ctl_b[71]
+ ctl_b[72]
+ ctl_b[73]
+ ctl_b[74]
+ ctl_b[75]
+ ctl_b[76]
+ ctl_b[77]
+ ctl_b[78]
+ ctl_b[79]
+ ctl_b[80]
+ ctl_b[81]
+ ctl_b[82]
+ ctl_b[83]
+ ctl_b[84]
+ ctl_b[85]
+ ctl_b[86]
+ ctl_b[87]
+ ctl_b[88]
+ ctl_b[89]
+ ctl_b[90]
+ ctl_b[91]
+ ctl_b[92]
+ ctl_b[93]
+ ctl_b[94]
+ ctl_b[95]
+ ctl_b[96]
+ ctl_b[97]
+ ctl_b[98]
+ ctl_b[99]
+ ctl_b[100]
+ ctl_b[101]
+ ctl_b[102]
+ ctl_b[103]
+ ctl_b[104]
+ ctl_b[105]
+ ctl_b[106]
+ ctl_b[107]
+ ctl_b[108]
+ ctl_b[109]
+ ctl_b[110]
+ ctl_b[111]
+ ctl_b[112]
+ ctl_b[113]
+ ctl_b[114]
+ ctl_b[115]
+ ctl_b[116]
+ ctl_b[117]
+ ctl_b[118]
+ ctl_b[119]
+ ctl_b[120]
+ ctl_b[121]
+ ctl_b[122]
+ ctl_b[123]
+ ctl_b[124]
+ ctl_b[125]
+ ctl_b[126]
+ ctl_b[127]
+ vdd
+ vss

Xinv_0
+ vdd
+ vss
+ clk_in
+ clk_int_top[0]
+ inv
Xtristate_inv_mid_0
+ clk_int_top[0]
+ ctl[0]
+ ctl_b[0]
+ clk_out
+ vdd
+ vss
+ tristate_inv
Xinv_1
+ vdd
+ vss
+ clk_int_top[0]
+ clk_int_top[1]
+ inv
Xtristate_inv_mid_1
+ clk_int_top[1]
+ ctl[1]
+ ctl_b[1]
+ clk_int_bot[0]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_1
+ clk_int_bot[0]
+ ctl_b[0]
+ ctl[0]
+ clk_out
+ vdd
+ vss
+ tristate_inv
Xinv_2
+ vdd
+ vss
+ clk_int_top[1]
+ clk_int_top[2]
+ inv
Xtristate_inv_mid_2
+ clk_int_top[2]
+ ctl[2]
+ ctl_b[2]
+ clk_int_bot[1]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_2
+ clk_int_bot[1]
+ ctl_b[1]
+ ctl[1]
+ clk_int_bot[0]
+ vdd
+ vss
+ tristate_inv
Xinv_3
+ vdd
+ vss
+ clk_int_top[2]
+ clk_int_top[3]
+ inv
Xtristate_inv_mid_3
+ clk_int_top[3]
+ ctl[3]
+ ctl_b[3]
+ clk_int_bot[2]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_3
+ clk_int_bot[2]
+ ctl_b[2]
+ ctl[2]
+ clk_int_bot[1]
+ vdd
+ vss
+ tristate_inv
Xinv_4
+ vdd
+ vss
+ clk_int_top[3]
+ clk_int_top[4]
+ inv
Xtristate_inv_mid_4
+ clk_int_top[4]
+ ctl[4]
+ ctl_b[4]
+ clk_int_bot[3]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_4
+ clk_int_bot[3]
+ ctl_b[3]
+ ctl[3]
+ clk_int_bot[2]
+ vdd
+ vss
+ tristate_inv
Xinv_5
+ vdd
+ vss
+ clk_int_top[4]
+ clk_int_top[5]
+ inv
Xtristate_inv_mid_5
+ clk_int_top[5]
+ ctl[5]
+ ctl_b[5]
+ clk_int_bot[4]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_5
+ clk_int_bot[4]
+ ctl_b[4]
+ ctl[4]
+ clk_int_bot[3]
+ vdd
+ vss
+ tristate_inv
Xinv_6
+ vdd
+ vss
+ clk_int_top[5]
+ clk_int_top[6]
+ inv
Xtristate_inv_mid_6
+ clk_int_top[6]
+ ctl[6]
+ ctl_b[6]
+ clk_int_bot[5]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_6
+ clk_int_bot[5]
+ ctl_b[5]
+ ctl[5]
+ clk_int_bot[4]
+ vdd
+ vss
+ tristate_inv
Xinv_7
+ vdd
+ vss
+ clk_int_top[6]
+ clk_int_top[7]
+ inv
Xtristate_inv_mid_7
+ clk_int_top[7]
+ ctl[7]
+ ctl_b[7]
+ clk_int_bot[6]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_7
+ clk_int_bot[6]
+ ctl_b[6]
+ ctl[6]
+ clk_int_bot[5]
+ vdd
+ vss
+ tristate_inv
Xinv_8
+ vdd
+ vss
+ clk_int_top[7]
+ clk_int_top[8]
+ inv
Xtristate_inv_mid_8
+ clk_int_top[8]
+ ctl[8]
+ ctl_b[8]
+ clk_int_bot[7]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_8
+ clk_int_bot[7]
+ ctl_b[7]
+ ctl[7]
+ clk_int_bot[6]
+ vdd
+ vss
+ tristate_inv
Xinv_9
+ vdd
+ vss
+ clk_int_top[8]
+ clk_int_top[9]
+ inv
Xtristate_inv_mid_9
+ clk_int_top[9]
+ ctl[9]
+ ctl_b[9]
+ clk_int_bot[8]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_9
+ clk_int_bot[8]
+ ctl_b[8]
+ ctl[8]
+ clk_int_bot[7]
+ vdd
+ vss
+ tristate_inv
Xinv_10
+ vdd
+ vss
+ clk_int_top[9]
+ clk_int_top[10]
+ inv
Xtristate_inv_mid_10
+ clk_int_top[10]
+ ctl[10]
+ ctl_b[10]
+ clk_int_bot[9]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_10
+ clk_int_bot[9]
+ ctl_b[9]
+ ctl[9]
+ clk_int_bot[8]
+ vdd
+ vss
+ tristate_inv
Xinv_11
+ vdd
+ vss
+ clk_int_top[10]
+ clk_int_top[11]
+ inv
Xtristate_inv_mid_11
+ clk_int_top[11]
+ ctl[11]
+ ctl_b[11]
+ clk_int_bot[10]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_11
+ clk_int_bot[10]
+ ctl_b[10]
+ ctl[10]
+ clk_int_bot[9]
+ vdd
+ vss
+ tristate_inv
Xinv_12
+ vdd
+ vss
+ clk_int_top[11]
+ clk_int_top[12]
+ inv
Xtristate_inv_mid_12
+ clk_int_top[12]
+ ctl[12]
+ ctl_b[12]
+ clk_int_bot[11]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_12
+ clk_int_bot[11]
+ ctl_b[11]
+ ctl[11]
+ clk_int_bot[10]
+ vdd
+ vss
+ tristate_inv
Xinv_13
+ vdd
+ vss
+ clk_int_top[12]
+ clk_int_top[13]
+ inv
Xtristate_inv_mid_13
+ clk_int_top[13]
+ ctl[13]
+ ctl_b[13]
+ clk_int_bot[12]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_13
+ clk_int_bot[12]
+ ctl_b[12]
+ ctl[12]
+ clk_int_bot[11]
+ vdd
+ vss
+ tristate_inv
Xinv_14
+ vdd
+ vss
+ clk_int_top[13]
+ clk_int_top[14]
+ inv
Xtristate_inv_mid_14
+ clk_int_top[14]
+ ctl[14]
+ ctl_b[14]
+ clk_int_bot[13]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_14
+ clk_int_bot[13]
+ ctl_b[13]
+ ctl[13]
+ clk_int_bot[12]
+ vdd
+ vss
+ tristate_inv
Xinv_15
+ vdd
+ vss
+ clk_int_top[14]
+ clk_int_top[15]
+ inv
Xtristate_inv_mid_15
+ clk_int_top[15]
+ ctl[15]
+ ctl_b[15]
+ clk_int_bot[14]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_15
+ clk_int_bot[14]
+ ctl_b[14]
+ ctl[14]
+ clk_int_bot[13]
+ vdd
+ vss
+ tristate_inv
Xinv_16
+ vdd
+ vss
+ clk_int_top[15]
+ clk_int_top[16]
+ inv
Xtristate_inv_mid_16
+ clk_int_top[16]
+ ctl[16]
+ ctl_b[16]
+ clk_int_bot[15]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_16
+ clk_int_bot[15]
+ ctl_b[15]
+ ctl[15]
+ clk_int_bot[14]
+ vdd
+ vss
+ tristate_inv
Xinv_17
+ vdd
+ vss
+ clk_int_top[16]
+ clk_int_top[17]
+ inv
Xtristate_inv_mid_17
+ clk_int_top[17]
+ ctl[17]
+ ctl_b[17]
+ clk_int_bot[16]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_17
+ clk_int_bot[16]
+ ctl_b[16]
+ ctl[16]
+ clk_int_bot[15]
+ vdd
+ vss
+ tristate_inv
Xinv_18
+ vdd
+ vss
+ clk_int_top[17]
+ clk_int_top[18]
+ inv
Xtristate_inv_mid_18
+ clk_int_top[18]
+ ctl[18]
+ ctl_b[18]
+ clk_int_bot[17]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_18
+ clk_int_bot[17]
+ ctl_b[17]
+ ctl[17]
+ clk_int_bot[16]
+ vdd
+ vss
+ tristate_inv
Xinv_19
+ vdd
+ vss
+ clk_int_top[18]
+ clk_int_top[19]
+ inv
Xtristate_inv_mid_19
+ clk_int_top[19]
+ ctl[19]
+ ctl_b[19]
+ clk_int_bot[18]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_19
+ clk_int_bot[18]
+ ctl_b[18]
+ ctl[18]
+ clk_int_bot[17]
+ vdd
+ vss
+ tristate_inv
Xinv_20
+ vdd
+ vss
+ clk_int_top[19]
+ clk_int_top[20]
+ inv
Xtristate_inv_mid_20
+ clk_int_top[20]
+ ctl[20]
+ ctl_b[20]
+ clk_int_bot[19]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_20
+ clk_int_bot[19]
+ ctl_b[19]
+ ctl[19]
+ clk_int_bot[18]
+ vdd
+ vss
+ tristate_inv
Xinv_21
+ vdd
+ vss
+ clk_int_top[20]
+ clk_int_top[21]
+ inv
Xtristate_inv_mid_21
+ clk_int_top[21]
+ ctl[21]
+ ctl_b[21]
+ clk_int_bot[20]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_21
+ clk_int_bot[20]
+ ctl_b[20]
+ ctl[20]
+ clk_int_bot[19]
+ vdd
+ vss
+ tristate_inv
Xinv_22
+ vdd
+ vss
+ clk_int_top[21]
+ clk_int_top[22]
+ inv
Xtristate_inv_mid_22
+ clk_int_top[22]
+ ctl[22]
+ ctl_b[22]
+ clk_int_bot[21]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_22
+ clk_int_bot[21]
+ ctl_b[21]
+ ctl[21]
+ clk_int_bot[20]
+ vdd
+ vss
+ tristate_inv
Xinv_23
+ vdd
+ vss
+ clk_int_top[22]
+ clk_int_top[23]
+ inv
Xtristate_inv_mid_23
+ clk_int_top[23]
+ ctl[23]
+ ctl_b[23]
+ clk_int_bot[22]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_23
+ clk_int_bot[22]
+ ctl_b[22]
+ ctl[22]
+ clk_int_bot[21]
+ vdd
+ vss
+ tristate_inv
Xinv_24
+ vdd
+ vss
+ clk_int_top[23]
+ clk_int_top[24]
+ inv
Xtristate_inv_mid_24
+ clk_int_top[24]
+ ctl[24]
+ ctl_b[24]
+ clk_int_bot[23]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_24
+ clk_int_bot[23]
+ ctl_b[23]
+ ctl[23]
+ clk_int_bot[22]
+ vdd
+ vss
+ tristate_inv
Xinv_25
+ vdd
+ vss
+ clk_int_top[24]
+ clk_int_top[25]
+ inv
Xtristate_inv_mid_25
+ clk_int_top[25]
+ ctl[25]
+ ctl_b[25]
+ clk_int_bot[24]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_25
+ clk_int_bot[24]
+ ctl_b[24]
+ ctl[24]
+ clk_int_bot[23]
+ vdd
+ vss
+ tristate_inv
Xinv_26
+ vdd
+ vss
+ clk_int_top[25]
+ clk_int_top[26]
+ inv
Xtristate_inv_mid_26
+ clk_int_top[26]
+ ctl[26]
+ ctl_b[26]
+ clk_int_bot[25]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_26
+ clk_int_bot[25]
+ ctl_b[25]
+ ctl[25]
+ clk_int_bot[24]
+ vdd
+ vss
+ tristate_inv
Xinv_27
+ vdd
+ vss
+ clk_int_top[26]
+ clk_int_top[27]
+ inv
Xtristate_inv_mid_27
+ clk_int_top[27]
+ ctl[27]
+ ctl_b[27]
+ clk_int_bot[26]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_27
+ clk_int_bot[26]
+ ctl_b[26]
+ ctl[26]
+ clk_int_bot[25]
+ vdd
+ vss
+ tristate_inv
Xinv_28
+ vdd
+ vss
+ clk_int_top[27]
+ clk_int_top[28]
+ inv
Xtristate_inv_mid_28
+ clk_int_top[28]
+ ctl[28]
+ ctl_b[28]
+ clk_int_bot[27]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_28
+ clk_int_bot[27]
+ ctl_b[27]
+ ctl[27]
+ clk_int_bot[26]
+ vdd
+ vss
+ tristate_inv
Xinv_29
+ vdd
+ vss
+ clk_int_top[28]
+ clk_int_top[29]
+ inv
Xtristate_inv_mid_29
+ clk_int_top[29]
+ ctl[29]
+ ctl_b[29]
+ clk_int_bot[28]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_29
+ clk_int_bot[28]
+ ctl_b[28]
+ ctl[28]
+ clk_int_bot[27]
+ vdd
+ vss
+ tristate_inv
Xinv_30
+ vdd
+ vss
+ clk_int_top[29]
+ clk_int_top[30]
+ inv
Xtristate_inv_mid_30
+ clk_int_top[30]
+ ctl[30]
+ ctl_b[30]
+ clk_int_bot[29]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_30
+ clk_int_bot[29]
+ ctl_b[29]
+ ctl[29]
+ clk_int_bot[28]
+ vdd
+ vss
+ tristate_inv
Xinv_31
+ vdd
+ vss
+ clk_int_top[30]
+ clk_int_top[31]
+ inv
Xtristate_inv_mid_31
+ clk_int_top[31]
+ ctl[31]
+ ctl_b[31]
+ clk_int_bot[30]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_31
+ clk_int_bot[30]
+ ctl_b[30]
+ ctl[30]
+ clk_int_bot[29]
+ vdd
+ vss
+ tristate_inv
Xinv_32
+ vdd
+ vss
+ clk_int_top[31]
+ clk_int_top[32]
+ inv
Xtristate_inv_mid_32
+ clk_int_top[32]
+ ctl[32]
+ ctl_b[32]
+ clk_int_bot[31]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_32
+ clk_int_bot[31]
+ ctl_b[31]
+ ctl[31]
+ clk_int_bot[30]
+ vdd
+ vss
+ tristate_inv
Xinv_33
+ vdd
+ vss
+ clk_int_top[32]
+ clk_int_top[33]
+ inv
Xtristate_inv_mid_33
+ clk_int_top[33]
+ ctl[33]
+ ctl_b[33]
+ clk_int_bot[32]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_33
+ clk_int_bot[32]
+ ctl_b[32]
+ ctl[32]
+ clk_int_bot[31]
+ vdd
+ vss
+ tristate_inv
Xinv_34
+ vdd
+ vss
+ clk_int_top[33]
+ clk_int_top[34]
+ inv
Xtristate_inv_mid_34
+ clk_int_top[34]
+ ctl[34]
+ ctl_b[34]
+ clk_int_bot[33]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_34
+ clk_int_bot[33]
+ ctl_b[33]
+ ctl[33]
+ clk_int_bot[32]
+ vdd
+ vss
+ tristate_inv
Xinv_35
+ vdd
+ vss
+ clk_int_top[34]
+ clk_int_top[35]
+ inv
Xtristate_inv_mid_35
+ clk_int_top[35]
+ ctl[35]
+ ctl_b[35]
+ clk_int_bot[34]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_35
+ clk_int_bot[34]
+ ctl_b[34]
+ ctl[34]
+ clk_int_bot[33]
+ vdd
+ vss
+ tristate_inv
Xinv_36
+ vdd
+ vss
+ clk_int_top[35]
+ clk_int_top[36]
+ inv
Xtristate_inv_mid_36
+ clk_int_top[36]
+ ctl[36]
+ ctl_b[36]
+ clk_int_bot[35]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_36
+ clk_int_bot[35]
+ ctl_b[35]
+ ctl[35]
+ clk_int_bot[34]
+ vdd
+ vss
+ tristate_inv
Xinv_37
+ vdd
+ vss
+ clk_int_top[36]
+ clk_int_top[37]
+ inv
Xtristate_inv_mid_37
+ clk_int_top[37]
+ ctl[37]
+ ctl_b[37]
+ clk_int_bot[36]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_37
+ clk_int_bot[36]
+ ctl_b[36]
+ ctl[36]
+ clk_int_bot[35]
+ vdd
+ vss
+ tristate_inv
Xinv_38
+ vdd
+ vss
+ clk_int_top[37]
+ clk_int_top[38]
+ inv
Xtristate_inv_mid_38
+ clk_int_top[38]
+ ctl[38]
+ ctl_b[38]
+ clk_int_bot[37]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_38
+ clk_int_bot[37]
+ ctl_b[37]
+ ctl[37]
+ clk_int_bot[36]
+ vdd
+ vss
+ tristate_inv
Xinv_39
+ vdd
+ vss
+ clk_int_top[38]
+ clk_int_top[39]
+ inv
Xtristate_inv_mid_39
+ clk_int_top[39]
+ ctl[39]
+ ctl_b[39]
+ clk_int_bot[38]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_39
+ clk_int_bot[38]
+ ctl_b[38]
+ ctl[38]
+ clk_int_bot[37]
+ vdd
+ vss
+ tristate_inv
Xinv_40
+ vdd
+ vss
+ clk_int_top[39]
+ clk_int_top[40]
+ inv
Xtristate_inv_mid_40
+ clk_int_top[40]
+ ctl[40]
+ ctl_b[40]
+ clk_int_bot[39]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_40
+ clk_int_bot[39]
+ ctl_b[39]
+ ctl[39]
+ clk_int_bot[38]
+ vdd
+ vss
+ tristate_inv
Xinv_41
+ vdd
+ vss
+ clk_int_top[40]
+ clk_int_top[41]
+ inv
Xtristate_inv_mid_41
+ clk_int_top[41]
+ ctl[41]
+ ctl_b[41]
+ clk_int_bot[40]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_41
+ clk_int_bot[40]
+ ctl_b[40]
+ ctl[40]
+ clk_int_bot[39]
+ vdd
+ vss
+ tristate_inv
Xinv_42
+ vdd
+ vss
+ clk_int_top[41]
+ clk_int_top[42]
+ inv
Xtristate_inv_mid_42
+ clk_int_top[42]
+ ctl[42]
+ ctl_b[42]
+ clk_int_bot[41]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_42
+ clk_int_bot[41]
+ ctl_b[41]
+ ctl[41]
+ clk_int_bot[40]
+ vdd
+ vss
+ tristate_inv
Xinv_43
+ vdd
+ vss
+ clk_int_top[42]
+ clk_int_top[43]
+ inv
Xtristate_inv_mid_43
+ clk_int_top[43]
+ ctl[43]
+ ctl_b[43]
+ clk_int_bot[42]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_43
+ clk_int_bot[42]
+ ctl_b[42]
+ ctl[42]
+ clk_int_bot[41]
+ vdd
+ vss
+ tristate_inv
Xinv_44
+ vdd
+ vss
+ clk_int_top[43]
+ clk_int_top[44]
+ inv
Xtristate_inv_mid_44
+ clk_int_top[44]
+ ctl[44]
+ ctl_b[44]
+ clk_int_bot[43]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_44
+ clk_int_bot[43]
+ ctl_b[43]
+ ctl[43]
+ clk_int_bot[42]
+ vdd
+ vss
+ tristate_inv
Xinv_45
+ vdd
+ vss
+ clk_int_top[44]
+ clk_int_top[45]
+ inv
Xtristate_inv_mid_45
+ clk_int_top[45]
+ ctl[45]
+ ctl_b[45]
+ clk_int_bot[44]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_45
+ clk_int_bot[44]
+ ctl_b[44]
+ ctl[44]
+ clk_int_bot[43]
+ vdd
+ vss
+ tristate_inv
Xinv_46
+ vdd
+ vss
+ clk_int_top[45]
+ clk_int_top[46]
+ inv
Xtristate_inv_mid_46
+ clk_int_top[46]
+ ctl[46]
+ ctl_b[46]
+ clk_int_bot[45]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_46
+ clk_int_bot[45]
+ ctl_b[45]
+ ctl[45]
+ clk_int_bot[44]
+ vdd
+ vss
+ tristate_inv
Xinv_47
+ vdd
+ vss
+ clk_int_top[46]
+ clk_int_top[47]
+ inv
Xtristate_inv_mid_47
+ clk_int_top[47]
+ ctl[47]
+ ctl_b[47]
+ clk_int_bot[46]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_47
+ clk_int_bot[46]
+ ctl_b[46]
+ ctl[46]
+ clk_int_bot[45]
+ vdd
+ vss
+ tristate_inv
Xinv_48
+ vdd
+ vss
+ clk_int_top[47]
+ clk_int_top[48]
+ inv
Xtristate_inv_mid_48
+ clk_int_top[48]
+ ctl[48]
+ ctl_b[48]
+ clk_int_bot[47]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_48
+ clk_int_bot[47]
+ ctl_b[47]
+ ctl[47]
+ clk_int_bot[46]
+ vdd
+ vss
+ tristate_inv
Xinv_49
+ vdd
+ vss
+ clk_int_top[48]
+ clk_int_top[49]
+ inv
Xtristate_inv_mid_49
+ clk_int_top[49]
+ ctl[49]
+ ctl_b[49]
+ clk_int_bot[48]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_49
+ clk_int_bot[48]
+ ctl_b[48]
+ ctl[48]
+ clk_int_bot[47]
+ vdd
+ vss
+ tristate_inv
Xinv_50
+ vdd
+ vss
+ clk_int_top[49]
+ clk_int_top[50]
+ inv
Xtristate_inv_mid_50
+ clk_int_top[50]
+ ctl[50]
+ ctl_b[50]
+ clk_int_bot[49]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_50
+ clk_int_bot[49]
+ ctl_b[49]
+ ctl[49]
+ clk_int_bot[48]
+ vdd
+ vss
+ tristate_inv
Xinv_51
+ vdd
+ vss
+ clk_int_top[50]
+ clk_int_top[51]
+ inv
Xtristate_inv_mid_51
+ clk_int_top[51]
+ ctl[51]
+ ctl_b[51]
+ clk_int_bot[50]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_51
+ clk_int_bot[50]
+ ctl_b[50]
+ ctl[50]
+ clk_int_bot[49]
+ vdd
+ vss
+ tristate_inv
Xinv_52
+ vdd
+ vss
+ clk_int_top[51]
+ clk_int_top[52]
+ inv
Xtristate_inv_mid_52
+ clk_int_top[52]
+ ctl[52]
+ ctl_b[52]
+ clk_int_bot[51]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_52
+ clk_int_bot[51]
+ ctl_b[51]
+ ctl[51]
+ clk_int_bot[50]
+ vdd
+ vss
+ tristate_inv
Xinv_53
+ vdd
+ vss
+ clk_int_top[52]
+ clk_int_top[53]
+ inv
Xtristate_inv_mid_53
+ clk_int_top[53]
+ ctl[53]
+ ctl_b[53]
+ clk_int_bot[52]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_53
+ clk_int_bot[52]
+ ctl_b[52]
+ ctl[52]
+ clk_int_bot[51]
+ vdd
+ vss
+ tristate_inv
Xinv_54
+ vdd
+ vss
+ clk_int_top[53]
+ clk_int_top[54]
+ inv
Xtristate_inv_mid_54
+ clk_int_top[54]
+ ctl[54]
+ ctl_b[54]
+ clk_int_bot[53]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_54
+ clk_int_bot[53]
+ ctl_b[53]
+ ctl[53]
+ clk_int_bot[52]
+ vdd
+ vss
+ tristate_inv
Xinv_55
+ vdd
+ vss
+ clk_int_top[54]
+ clk_int_top[55]
+ inv
Xtristate_inv_mid_55
+ clk_int_top[55]
+ ctl[55]
+ ctl_b[55]
+ clk_int_bot[54]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_55
+ clk_int_bot[54]
+ ctl_b[54]
+ ctl[54]
+ clk_int_bot[53]
+ vdd
+ vss
+ tristate_inv
Xinv_56
+ vdd
+ vss
+ clk_int_top[55]
+ clk_int_top[56]
+ inv
Xtristate_inv_mid_56
+ clk_int_top[56]
+ ctl[56]
+ ctl_b[56]
+ clk_int_bot[55]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_56
+ clk_int_bot[55]
+ ctl_b[55]
+ ctl[55]
+ clk_int_bot[54]
+ vdd
+ vss
+ tristate_inv
Xinv_57
+ vdd
+ vss
+ clk_int_top[56]
+ clk_int_top[57]
+ inv
Xtristate_inv_mid_57
+ clk_int_top[57]
+ ctl[57]
+ ctl_b[57]
+ clk_int_bot[56]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_57
+ clk_int_bot[56]
+ ctl_b[56]
+ ctl[56]
+ clk_int_bot[55]
+ vdd
+ vss
+ tristate_inv
Xinv_58
+ vdd
+ vss
+ clk_int_top[57]
+ clk_int_top[58]
+ inv
Xtristate_inv_mid_58
+ clk_int_top[58]
+ ctl[58]
+ ctl_b[58]
+ clk_int_bot[57]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_58
+ clk_int_bot[57]
+ ctl_b[57]
+ ctl[57]
+ clk_int_bot[56]
+ vdd
+ vss
+ tristate_inv
Xinv_59
+ vdd
+ vss
+ clk_int_top[58]
+ clk_int_top[59]
+ inv
Xtristate_inv_mid_59
+ clk_int_top[59]
+ ctl[59]
+ ctl_b[59]
+ clk_int_bot[58]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_59
+ clk_int_bot[58]
+ ctl_b[58]
+ ctl[58]
+ clk_int_bot[57]
+ vdd
+ vss
+ tristate_inv
Xinv_60
+ vdd
+ vss
+ clk_int_top[59]
+ clk_int_top[60]
+ inv
Xtristate_inv_mid_60
+ clk_int_top[60]
+ ctl[60]
+ ctl_b[60]
+ clk_int_bot[59]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_60
+ clk_int_bot[59]
+ ctl_b[59]
+ ctl[59]
+ clk_int_bot[58]
+ vdd
+ vss
+ tristate_inv
Xinv_61
+ vdd
+ vss
+ clk_int_top[60]
+ clk_int_top[61]
+ inv
Xtristate_inv_mid_61
+ clk_int_top[61]
+ ctl[61]
+ ctl_b[61]
+ clk_int_bot[60]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_61
+ clk_int_bot[60]
+ ctl_b[60]
+ ctl[60]
+ clk_int_bot[59]
+ vdd
+ vss
+ tristate_inv
Xinv_62
+ vdd
+ vss
+ clk_int_top[61]
+ clk_int_top[62]
+ inv
Xtristate_inv_mid_62
+ clk_int_top[62]
+ ctl[62]
+ ctl_b[62]
+ clk_int_bot[61]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_62
+ clk_int_bot[61]
+ ctl_b[61]
+ ctl[61]
+ clk_int_bot[60]
+ vdd
+ vss
+ tristate_inv
Xinv_63
+ vdd
+ vss
+ clk_int_top[62]
+ clk_int_top[63]
+ inv
Xtristate_inv_mid_63
+ clk_int_top[63]
+ ctl[63]
+ ctl_b[63]
+ clk_int_bot[62]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_63
+ clk_int_bot[62]
+ ctl_b[62]
+ ctl[62]
+ clk_int_bot[61]
+ vdd
+ vss
+ tristate_inv
Xinv_64
+ vdd
+ vss
+ clk_int_top[63]
+ clk_int_top[64]
+ inv
Xtristate_inv_mid_64
+ clk_int_top[64]
+ ctl[64]
+ ctl_b[64]
+ clk_int_bot[63]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_64
+ clk_int_bot[63]
+ ctl_b[63]
+ ctl[63]
+ clk_int_bot[62]
+ vdd
+ vss
+ tristate_inv
Xinv_65
+ vdd
+ vss
+ clk_int_top[64]
+ clk_int_top[65]
+ inv
Xtristate_inv_mid_65
+ clk_int_top[65]
+ ctl[65]
+ ctl_b[65]
+ clk_int_bot[64]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_65
+ clk_int_bot[64]
+ ctl_b[64]
+ ctl[64]
+ clk_int_bot[63]
+ vdd
+ vss
+ tristate_inv
Xinv_66
+ vdd
+ vss
+ clk_int_top[65]
+ clk_int_top[66]
+ inv
Xtristate_inv_mid_66
+ clk_int_top[66]
+ ctl[66]
+ ctl_b[66]
+ clk_int_bot[65]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_66
+ clk_int_bot[65]
+ ctl_b[65]
+ ctl[65]
+ clk_int_bot[64]
+ vdd
+ vss
+ tristate_inv
Xinv_67
+ vdd
+ vss
+ clk_int_top[66]
+ clk_int_top[67]
+ inv
Xtristate_inv_mid_67
+ clk_int_top[67]
+ ctl[67]
+ ctl_b[67]
+ clk_int_bot[66]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_67
+ clk_int_bot[66]
+ ctl_b[66]
+ ctl[66]
+ clk_int_bot[65]
+ vdd
+ vss
+ tristate_inv
Xinv_68
+ vdd
+ vss
+ clk_int_top[67]
+ clk_int_top[68]
+ inv
Xtristate_inv_mid_68
+ clk_int_top[68]
+ ctl[68]
+ ctl_b[68]
+ clk_int_bot[67]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_68
+ clk_int_bot[67]
+ ctl_b[67]
+ ctl[67]
+ clk_int_bot[66]
+ vdd
+ vss
+ tristate_inv
Xinv_69
+ vdd
+ vss
+ clk_int_top[68]
+ clk_int_top[69]
+ inv
Xtristate_inv_mid_69
+ clk_int_top[69]
+ ctl[69]
+ ctl_b[69]
+ clk_int_bot[68]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_69
+ clk_int_bot[68]
+ ctl_b[68]
+ ctl[68]
+ clk_int_bot[67]
+ vdd
+ vss
+ tristate_inv
Xinv_70
+ vdd
+ vss
+ clk_int_top[69]
+ clk_int_top[70]
+ inv
Xtristate_inv_mid_70
+ clk_int_top[70]
+ ctl[70]
+ ctl_b[70]
+ clk_int_bot[69]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_70
+ clk_int_bot[69]
+ ctl_b[69]
+ ctl[69]
+ clk_int_bot[68]
+ vdd
+ vss
+ tristate_inv
Xinv_71
+ vdd
+ vss
+ clk_int_top[70]
+ clk_int_top[71]
+ inv
Xtristate_inv_mid_71
+ clk_int_top[71]
+ ctl[71]
+ ctl_b[71]
+ clk_int_bot[70]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_71
+ clk_int_bot[70]
+ ctl_b[70]
+ ctl[70]
+ clk_int_bot[69]
+ vdd
+ vss
+ tristate_inv
Xinv_72
+ vdd
+ vss
+ clk_int_top[71]
+ clk_int_top[72]
+ inv
Xtristate_inv_mid_72
+ clk_int_top[72]
+ ctl[72]
+ ctl_b[72]
+ clk_int_bot[71]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_72
+ clk_int_bot[71]
+ ctl_b[71]
+ ctl[71]
+ clk_int_bot[70]
+ vdd
+ vss
+ tristate_inv
Xinv_73
+ vdd
+ vss
+ clk_int_top[72]
+ clk_int_top[73]
+ inv
Xtristate_inv_mid_73
+ clk_int_top[73]
+ ctl[73]
+ ctl_b[73]
+ clk_int_bot[72]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_73
+ clk_int_bot[72]
+ ctl_b[72]
+ ctl[72]
+ clk_int_bot[71]
+ vdd
+ vss
+ tristate_inv
Xinv_74
+ vdd
+ vss
+ clk_int_top[73]
+ clk_int_top[74]
+ inv
Xtristate_inv_mid_74
+ clk_int_top[74]
+ ctl[74]
+ ctl_b[74]
+ clk_int_bot[73]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_74
+ clk_int_bot[73]
+ ctl_b[73]
+ ctl[73]
+ clk_int_bot[72]
+ vdd
+ vss
+ tristate_inv
Xinv_75
+ vdd
+ vss
+ clk_int_top[74]
+ clk_int_top[75]
+ inv
Xtristate_inv_mid_75
+ clk_int_top[75]
+ ctl[75]
+ ctl_b[75]
+ clk_int_bot[74]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_75
+ clk_int_bot[74]
+ ctl_b[74]
+ ctl[74]
+ clk_int_bot[73]
+ vdd
+ vss
+ tristate_inv
Xinv_76
+ vdd
+ vss
+ clk_int_top[75]
+ clk_int_top[76]
+ inv
Xtristate_inv_mid_76
+ clk_int_top[76]
+ ctl[76]
+ ctl_b[76]
+ clk_int_bot[75]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_76
+ clk_int_bot[75]
+ ctl_b[75]
+ ctl[75]
+ clk_int_bot[74]
+ vdd
+ vss
+ tristate_inv
Xinv_77
+ vdd
+ vss
+ clk_int_top[76]
+ clk_int_top[77]
+ inv
Xtristate_inv_mid_77
+ clk_int_top[77]
+ ctl[77]
+ ctl_b[77]
+ clk_int_bot[76]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_77
+ clk_int_bot[76]
+ ctl_b[76]
+ ctl[76]
+ clk_int_bot[75]
+ vdd
+ vss
+ tristate_inv
Xinv_78
+ vdd
+ vss
+ clk_int_top[77]
+ clk_int_top[78]
+ inv
Xtristate_inv_mid_78
+ clk_int_top[78]
+ ctl[78]
+ ctl_b[78]
+ clk_int_bot[77]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_78
+ clk_int_bot[77]
+ ctl_b[77]
+ ctl[77]
+ clk_int_bot[76]
+ vdd
+ vss
+ tristate_inv
Xinv_79
+ vdd
+ vss
+ clk_int_top[78]
+ clk_int_top[79]
+ inv
Xtristate_inv_mid_79
+ clk_int_top[79]
+ ctl[79]
+ ctl_b[79]
+ clk_int_bot[78]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_79
+ clk_int_bot[78]
+ ctl_b[78]
+ ctl[78]
+ clk_int_bot[77]
+ vdd
+ vss
+ tristate_inv
Xinv_80
+ vdd
+ vss
+ clk_int_top[79]
+ clk_int_top[80]
+ inv
Xtristate_inv_mid_80
+ clk_int_top[80]
+ ctl[80]
+ ctl_b[80]
+ clk_int_bot[79]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_80
+ clk_int_bot[79]
+ ctl_b[79]
+ ctl[79]
+ clk_int_bot[78]
+ vdd
+ vss
+ tristate_inv
Xinv_81
+ vdd
+ vss
+ clk_int_top[80]
+ clk_int_top[81]
+ inv
Xtristate_inv_mid_81
+ clk_int_top[81]
+ ctl[81]
+ ctl_b[81]
+ clk_int_bot[80]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_81
+ clk_int_bot[80]
+ ctl_b[80]
+ ctl[80]
+ clk_int_bot[79]
+ vdd
+ vss
+ tristate_inv
Xinv_82
+ vdd
+ vss
+ clk_int_top[81]
+ clk_int_top[82]
+ inv
Xtristate_inv_mid_82
+ clk_int_top[82]
+ ctl[82]
+ ctl_b[82]
+ clk_int_bot[81]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_82
+ clk_int_bot[81]
+ ctl_b[81]
+ ctl[81]
+ clk_int_bot[80]
+ vdd
+ vss
+ tristate_inv
Xinv_83
+ vdd
+ vss
+ clk_int_top[82]
+ clk_int_top[83]
+ inv
Xtristate_inv_mid_83
+ clk_int_top[83]
+ ctl[83]
+ ctl_b[83]
+ clk_int_bot[82]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_83
+ clk_int_bot[82]
+ ctl_b[82]
+ ctl[82]
+ clk_int_bot[81]
+ vdd
+ vss
+ tristate_inv
Xinv_84
+ vdd
+ vss
+ clk_int_top[83]
+ clk_int_top[84]
+ inv
Xtristate_inv_mid_84
+ clk_int_top[84]
+ ctl[84]
+ ctl_b[84]
+ clk_int_bot[83]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_84
+ clk_int_bot[83]
+ ctl_b[83]
+ ctl[83]
+ clk_int_bot[82]
+ vdd
+ vss
+ tristate_inv
Xinv_85
+ vdd
+ vss
+ clk_int_top[84]
+ clk_int_top[85]
+ inv
Xtristate_inv_mid_85
+ clk_int_top[85]
+ ctl[85]
+ ctl_b[85]
+ clk_int_bot[84]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_85
+ clk_int_bot[84]
+ ctl_b[84]
+ ctl[84]
+ clk_int_bot[83]
+ vdd
+ vss
+ tristate_inv
Xinv_86
+ vdd
+ vss
+ clk_int_top[85]
+ clk_int_top[86]
+ inv
Xtristate_inv_mid_86
+ clk_int_top[86]
+ ctl[86]
+ ctl_b[86]
+ clk_int_bot[85]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_86
+ clk_int_bot[85]
+ ctl_b[85]
+ ctl[85]
+ clk_int_bot[84]
+ vdd
+ vss
+ tristate_inv
Xinv_87
+ vdd
+ vss
+ clk_int_top[86]
+ clk_int_top[87]
+ inv
Xtristate_inv_mid_87
+ clk_int_top[87]
+ ctl[87]
+ ctl_b[87]
+ clk_int_bot[86]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_87
+ clk_int_bot[86]
+ ctl_b[86]
+ ctl[86]
+ clk_int_bot[85]
+ vdd
+ vss
+ tristate_inv
Xinv_88
+ vdd
+ vss
+ clk_int_top[87]
+ clk_int_top[88]
+ inv
Xtristate_inv_mid_88
+ clk_int_top[88]
+ ctl[88]
+ ctl_b[88]
+ clk_int_bot[87]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_88
+ clk_int_bot[87]
+ ctl_b[87]
+ ctl[87]
+ clk_int_bot[86]
+ vdd
+ vss
+ tristate_inv
Xinv_89
+ vdd
+ vss
+ clk_int_top[88]
+ clk_int_top[89]
+ inv
Xtristate_inv_mid_89
+ clk_int_top[89]
+ ctl[89]
+ ctl_b[89]
+ clk_int_bot[88]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_89
+ clk_int_bot[88]
+ ctl_b[88]
+ ctl[88]
+ clk_int_bot[87]
+ vdd
+ vss
+ tristate_inv
Xinv_90
+ vdd
+ vss
+ clk_int_top[89]
+ clk_int_top[90]
+ inv
Xtristate_inv_mid_90
+ clk_int_top[90]
+ ctl[90]
+ ctl_b[90]
+ clk_int_bot[89]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_90
+ clk_int_bot[89]
+ ctl_b[89]
+ ctl[89]
+ clk_int_bot[88]
+ vdd
+ vss
+ tristate_inv
Xinv_91
+ vdd
+ vss
+ clk_int_top[90]
+ clk_int_top[91]
+ inv
Xtristate_inv_mid_91
+ clk_int_top[91]
+ ctl[91]
+ ctl_b[91]
+ clk_int_bot[90]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_91
+ clk_int_bot[90]
+ ctl_b[90]
+ ctl[90]
+ clk_int_bot[89]
+ vdd
+ vss
+ tristate_inv
Xinv_92
+ vdd
+ vss
+ clk_int_top[91]
+ clk_int_top[92]
+ inv
Xtristate_inv_mid_92
+ clk_int_top[92]
+ ctl[92]
+ ctl_b[92]
+ clk_int_bot[91]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_92
+ clk_int_bot[91]
+ ctl_b[91]
+ ctl[91]
+ clk_int_bot[90]
+ vdd
+ vss
+ tristate_inv
Xinv_93
+ vdd
+ vss
+ clk_int_top[92]
+ clk_int_top[93]
+ inv
Xtristate_inv_mid_93
+ clk_int_top[93]
+ ctl[93]
+ ctl_b[93]
+ clk_int_bot[92]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_93
+ clk_int_bot[92]
+ ctl_b[92]
+ ctl[92]
+ clk_int_bot[91]
+ vdd
+ vss
+ tristate_inv
Xinv_94
+ vdd
+ vss
+ clk_int_top[93]
+ clk_int_top[94]
+ inv
Xtristate_inv_mid_94
+ clk_int_top[94]
+ ctl[94]
+ ctl_b[94]
+ clk_int_bot[93]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_94
+ clk_int_bot[93]
+ ctl_b[93]
+ ctl[93]
+ clk_int_bot[92]
+ vdd
+ vss
+ tristate_inv
Xinv_95
+ vdd
+ vss
+ clk_int_top[94]
+ clk_int_top[95]
+ inv
Xtristate_inv_mid_95
+ clk_int_top[95]
+ ctl[95]
+ ctl_b[95]
+ clk_int_bot[94]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_95
+ clk_int_bot[94]
+ ctl_b[94]
+ ctl[94]
+ clk_int_bot[93]
+ vdd
+ vss
+ tristate_inv
Xinv_96
+ vdd
+ vss
+ clk_int_top[95]
+ clk_int_top[96]
+ inv
Xtristate_inv_mid_96
+ clk_int_top[96]
+ ctl[96]
+ ctl_b[96]
+ clk_int_bot[95]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_96
+ clk_int_bot[95]
+ ctl_b[95]
+ ctl[95]
+ clk_int_bot[94]
+ vdd
+ vss
+ tristate_inv
Xinv_97
+ vdd
+ vss
+ clk_int_top[96]
+ clk_int_top[97]
+ inv
Xtristate_inv_mid_97
+ clk_int_top[97]
+ ctl[97]
+ ctl_b[97]
+ clk_int_bot[96]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_97
+ clk_int_bot[96]
+ ctl_b[96]
+ ctl[96]
+ clk_int_bot[95]
+ vdd
+ vss
+ tristate_inv
Xinv_98
+ vdd
+ vss
+ clk_int_top[97]
+ clk_int_top[98]
+ inv
Xtristate_inv_mid_98
+ clk_int_top[98]
+ ctl[98]
+ ctl_b[98]
+ clk_int_bot[97]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_98
+ clk_int_bot[97]
+ ctl_b[97]
+ ctl[97]
+ clk_int_bot[96]
+ vdd
+ vss
+ tristate_inv
Xinv_99
+ vdd
+ vss
+ clk_int_top[98]
+ clk_int_top[99]
+ inv
Xtristate_inv_mid_99
+ clk_int_top[99]
+ ctl[99]
+ ctl_b[99]
+ clk_int_bot[98]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_99
+ clk_int_bot[98]
+ ctl_b[98]
+ ctl[98]
+ clk_int_bot[97]
+ vdd
+ vss
+ tristate_inv
Xinv_100
+ vdd
+ vss
+ clk_int_top[99]
+ clk_int_top[100]
+ inv
Xtristate_inv_mid_100
+ clk_int_top[100]
+ ctl[100]
+ ctl_b[100]
+ clk_int_bot[99]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_100
+ clk_int_bot[99]
+ ctl_b[99]
+ ctl[99]
+ clk_int_bot[98]
+ vdd
+ vss
+ tristate_inv
Xinv_101
+ vdd
+ vss
+ clk_int_top[100]
+ clk_int_top[101]
+ inv
Xtristate_inv_mid_101
+ clk_int_top[101]
+ ctl[101]
+ ctl_b[101]
+ clk_int_bot[100]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_101
+ clk_int_bot[100]
+ ctl_b[100]
+ ctl[100]
+ clk_int_bot[99]
+ vdd
+ vss
+ tristate_inv
Xinv_102
+ vdd
+ vss
+ clk_int_top[101]
+ clk_int_top[102]
+ inv
Xtristate_inv_mid_102
+ clk_int_top[102]
+ ctl[102]
+ ctl_b[102]
+ clk_int_bot[101]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_102
+ clk_int_bot[101]
+ ctl_b[101]
+ ctl[101]
+ clk_int_bot[100]
+ vdd
+ vss
+ tristate_inv
Xinv_103
+ vdd
+ vss
+ clk_int_top[102]
+ clk_int_top[103]
+ inv
Xtristate_inv_mid_103
+ clk_int_top[103]
+ ctl[103]
+ ctl_b[103]
+ clk_int_bot[102]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_103
+ clk_int_bot[102]
+ ctl_b[102]
+ ctl[102]
+ clk_int_bot[101]
+ vdd
+ vss
+ tristate_inv
Xinv_104
+ vdd
+ vss
+ clk_int_top[103]
+ clk_int_top[104]
+ inv
Xtristate_inv_mid_104
+ clk_int_top[104]
+ ctl[104]
+ ctl_b[104]
+ clk_int_bot[103]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_104
+ clk_int_bot[103]
+ ctl_b[103]
+ ctl[103]
+ clk_int_bot[102]
+ vdd
+ vss
+ tristate_inv
Xinv_105
+ vdd
+ vss
+ clk_int_top[104]
+ clk_int_top[105]
+ inv
Xtristate_inv_mid_105
+ clk_int_top[105]
+ ctl[105]
+ ctl_b[105]
+ clk_int_bot[104]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_105
+ clk_int_bot[104]
+ ctl_b[104]
+ ctl[104]
+ clk_int_bot[103]
+ vdd
+ vss
+ tristate_inv
Xinv_106
+ vdd
+ vss
+ clk_int_top[105]
+ clk_int_top[106]
+ inv
Xtristate_inv_mid_106
+ clk_int_top[106]
+ ctl[106]
+ ctl_b[106]
+ clk_int_bot[105]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_106
+ clk_int_bot[105]
+ ctl_b[105]
+ ctl[105]
+ clk_int_bot[104]
+ vdd
+ vss
+ tristate_inv
Xinv_107
+ vdd
+ vss
+ clk_int_top[106]
+ clk_int_top[107]
+ inv
Xtristate_inv_mid_107
+ clk_int_top[107]
+ ctl[107]
+ ctl_b[107]
+ clk_int_bot[106]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_107
+ clk_int_bot[106]
+ ctl_b[106]
+ ctl[106]
+ clk_int_bot[105]
+ vdd
+ vss
+ tristate_inv
Xinv_108
+ vdd
+ vss
+ clk_int_top[107]
+ clk_int_top[108]
+ inv
Xtristate_inv_mid_108
+ clk_int_top[108]
+ ctl[108]
+ ctl_b[108]
+ clk_int_bot[107]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_108
+ clk_int_bot[107]
+ ctl_b[107]
+ ctl[107]
+ clk_int_bot[106]
+ vdd
+ vss
+ tristate_inv
Xinv_109
+ vdd
+ vss
+ clk_int_top[108]
+ clk_int_top[109]
+ inv
Xtristate_inv_mid_109
+ clk_int_top[109]
+ ctl[109]
+ ctl_b[109]
+ clk_int_bot[108]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_109
+ clk_int_bot[108]
+ ctl_b[108]
+ ctl[108]
+ clk_int_bot[107]
+ vdd
+ vss
+ tristate_inv
Xinv_110
+ vdd
+ vss
+ clk_int_top[109]
+ clk_int_top[110]
+ inv
Xtristate_inv_mid_110
+ clk_int_top[110]
+ ctl[110]
+ ctl_b[110]
+ clk_int_bot[109]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_110
+ clk_int_bot[109]
+ ctl_b[109]
+ ctl[109]
+ clk_int_bot[108]
+ vdd
+ vss
+ tristate_inv
Xinv_111
+ vdd
+ vss
+ clk_int_top[110]
+ clk_int_top[111]
+ inv
Xtristate_inv_mid_111
+ clk_int_top[111]
+ ctl[111]
+ ctl_b[111]
+ clk_int_bot[110]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_111
+ clk_int_bot[110]
+ ctl_b[110]
+ ctl[110]
+ clk_int_bot[109]
+ vdd
+ vss
+ tristate_inv
Xinv_112
+ vdd
+ vss
+ clk_int_top[111]
+ clk_int_top[112]
+ inv
Xtristate_inv_mid_112
+ clk_int_top[112]
+ ctl[112]
+ ctl_b[112]
+ clk_int_bot[111]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_112
+ clk_int_bot[111]
+ ctl_b[111]
+ ctl[111]
+ clk_int_bot[110]
+ vdd
+ vss
+ tristate_inv
Xinv_113
+ vdd
+ vss
+ clk_int_top[112]
+ clk_int_top[113]
+ inv
Xtristate_inv_mid_113
+ clk_int_top[113]
+ ctl[113]
+ ctl_b[113]
+ clk_int_bot[112]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_113
+ clk_int_bot[112]
+ ctl_b[112]
+ ctl[112]
+ clk_int_bot[111]
+ vdd
+ vss
+ tristate_inv
Xinv_114
+ vdd
+ vss
+ clk_int_top[113]
+ clk_int_top[114]
+ inv
Xtristate_inv_mid_114
+ clk_int_top[114]
+ ctl[114]
+ ctl_b[114]
+ clk_int_bot[113]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_114
+ clk_int_bot[113]
+ ctl_b[113]
+ ctl[113]
+ clk_int_bot[112]
+ vdd
+ vss
+ tristate_inv
Xinv_115
+ vdd
+ vss
+ clk_int_top[114]
+ clk_int_top[115]
+ inv
Xtristate_inv_mid_115
+ clk_int_top[115]
+ ctl[115]
+ ctl_b[115]
+ clk_int_bot[114]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_115
+ clk_int_bot[114]
+ ctl_b[114]
+ ctl[114]
+ clk_int_bot[113]
+ vdd
+ vss
+ tristate_inv
Xinv_116
+ vdd
+ vss
+ clk_int_top[115]
+ clk_int_top[116]
+ inv
Xtristate_inv_mid_116
+ clk_int_top[116]
+ ctl[116]
+ ctl_b[116]
+ clk_int_bot[115]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_116
+ clk_int_bot[115]
+ ctl_b[115]
+ ctl[115]
+ clk_int_bot[114]
+ vdd
+ vss
+ tristate_inv
Xinv_117
+ vdd
+ vss
+ clk_int_top[116]
+ clk_int_top[117]
+ inv
Xtristate_inv_mid_117
+ clk_int_top[117]
+ ctl[117]
+ ctl_b[117]
+ clk_int_bot[116]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_117
+ clk_int_bot[116]
+ ctl_b[116]
+ ctl[116]
+ clk_int_bot[115]
+ vdd
+ vss
+ tristate_inv
Xinv_118
+ vdd
+ vss
+ clk_int_top[117]
+ clk_int_top[118]
+ inv
Xtristate_inv_mid_118
+ clk_int_top[118]
+ ctl[118]
+ ctl_b[118]
+ clk_int_bot[117]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_118
+ clk_int_bot[117]
+ ctl_b[117]
+ ctl[117]
+ clk_int_bot[116]
+ vdd
+ vss
+ tristate_inv
Xinv_119
+ vdd
+ vss
+ clk_int_top[118]
+ clk_int_top[119]
+ inv
Xtristate_inv_mid_119
+ clk_int_top[119]
+ ctl[119]
+ ctl_b[119]
+ clk_int_bot[118]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_119
+ clk_int_bot[118]
+ ctl_b[118]
+ ctl[118]
+ clk_int_bot[117]
+ vdd
+ vss
+ tristate_inv
Xinv_120
+ vdd
+ vss
+ clk_int_top[119]
+ clk_int_top[120]
+ inv
Xtristate_inv_mid_120
+ clk_int_top[120]
+ ctl[120]
+ ctl_b[120]
+ clk_int_bot[119]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_120
+ clk_int_bot[119]
+ ctl_b[119]
+ ctl[119]
+ clk_int_bot[118]
+ vdd
+ vss
+ tristate_inv
Xinv_121
+ vdd
+ vss
+ clk_int_top[120]
+ clk_int_top[121]
+ inv
Xtristate_inv_mid_121
+ clk_int_top[121]
+ ctl[121]
+ ctl_b[121]
+ clk_int_bot[120]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_121
+ clk_int_bot[120]
+ ctl_b[120]
+ ctl[120]
+ clk_int_bot[119]
+ vdd
+ vss
+ tristate_inv
Xinv_122
+ vdd
+ vss
+ clk_int_top[121]
+ clk_int_top[122]
+ inv
Xtristate_inv_mid_122
+ clk_int_top[122]
+ ctl[122]
+ ctl_b[122]
+ clk_int_bot[121]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_122
+ clk_int_bot[121]
+ ctl_b[121]
+ ctl[121]
+ clk_int_bot[120]
+ vdd
+ vss
+ tristate_inv
Xinv_123
+ vdd
+ vss
+ clk_int_top[122]
+ clk_int_top[123]
+ inv
Xtristate_inv_mid_123
+ clk_int_top[123]
+ ctl[123]
+ ctl_b[123]
+ clk_int_bot[122]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_123
+ clk_int_bot[122]
+ ctl_b[122]
+ ctl[122]
+ clk_int_bot[121]
+ vdd
+ vss
+ tristate_inv
Xinv_124
+ vdd
+ vss
+ clk_int_top[123]
+ clk_int_top[124]
+ inv
Xtristate_inv_mid_124
+ clk_int_top[124]
+ ctl[124]
+ ctl_b[124]
+ clk_int_bot[123]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_124
+ clk_int_bot[123]
+ ctl_b[123]
+ ctl[123]
+ clk_int_bot[122]
+ vdd
+ vss
+ tristate_inv
Xinv_125
+ vdd
+ vss
+ clk_int_top[124]
+ clk_int_top[125]
+ inv
Xtristate_inv_mid_125
+ clk_int_top[125]
+ ctl[125]
+ ctl_b[125]
+ clk_int_bot[124]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_125
+ clk_int_bot[124]
+ ctl_b[124]
+ ctl[124]
+ clk_int_bot[123]
+ vdd
+ vss
+ tristate_inv
Xinv_126
+ vdd
+ vss
+ clk_int_top[125]
+ clk_int_top[126]
+ inv
Xtristate_inv_mid_126
+ clk_int_top[126]
+ ctl[126]
+ ctl_b[126]
+ clk_int_bot[125]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_126
+ clk_int_bot[125]
+ ctl_b[125]
+ ctl[125]
+ clk_int_bot[124]
+ vdd
+ vss
+ tristate_inv
Xinv_127
+ vdd
+ vss
+ clk_int_top[126]
+ clk_int_top[127]
+ inv
Xtristate_inv_mid_127
+ clk_int_top[127]
+ ctl[127]
+ ctl_b[127]
+ clk_int_bot[126]
+ vdd
+ vss
+ tristate_inv
Xtristate_inv_bot_127
+ clk_int_bot[126]
+ ctl_b[126]
+ ctl[126]
+ clk_int_bot[125]
+ vdd
+ vss
+ tristate_inv
.ends tristate_inv_delay_line_128

.subckt inv
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w1800_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1000_l150_m1_nf1_id0
.ends inv

.subckt tristate_inv
+ din
+ en
+ en_b
+ din_b
+ vdd
+ vss

Xmn_en
+ din_b
+ en
+ nint
+ vss
+ mos_w1000_l150_m1_nf1_id0
Xmn_pd
+ nint
+ din
+ vss
+ vss
+ mos_w1000_l150_m1_nf1_id0
Xmp_en
+ din_b
+ en_b
+ pint
+ vdd
+ mos_w1800_l150_m1_nf1_id1
Xmp_pu
+ pint
+ din
+ vdd
+ vdd
+ mos_w1800_l150_m1_nf1_id1
.ends tristate_inv

.subckt mos_w1800_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.800 l=0.150 nf=1 mult=1
.ends mos_w1800_l150_m1_nf1_id1

.subckt mos_w1000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=1.000 l=0.150 nf=1 mult=1
.ends mos_w1000_l150_m1_nf1_id0
